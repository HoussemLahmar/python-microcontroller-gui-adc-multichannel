# Keil uVision project 073-STM32F1_ADC_MULTI_CHANNEL_READ-Python-COM.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 073-STM32F1_ADC_MULTI_CHANNEL_READ-Python-COM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c adc_drive.c adc_drive.h gp_drive.c gp_drive.h help_func.c help_func.h msg_drive.c msg_drive.h systick_time.c systick_time.h uart_drive.c uart_drive.h timer_drive.c timer_drive.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
